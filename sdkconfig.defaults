## sdkconfig.defaults
```kconfig
CONFIG_ESP_CONSOLE_USB_CDC=y
CONFIG_USB_CDC_ENABLED=y
CONFIG_ESP_CONSOLE_STDOUT_USB_CDC=y
```
